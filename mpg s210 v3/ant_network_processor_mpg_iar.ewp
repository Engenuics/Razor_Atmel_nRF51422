# IAR project ant_network_processor_mpg_iar.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nRF51422-QFAA NordicSemi nRF51422-QFAA
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: Include; Source; Common\Include; Common\Source; SDK\Include; SDK\Include\s210
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: Include; Source; Common\Include; Common\Source
  OBJCOPY.OOCOutputFile: ant_network_processor_mpg_iar.hex
  ILINK.IlinkOutputFile: ant_network_processor_mpg_iar.out
  ILINK.IlinkIcfFile: Source\nRF51422_QFAA.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Common/Include
    Common/Include/: command.h dsi_utility.h global.h serial.h system.h
  group Common/Source
    Common/Source/: command.c dsi_utility.c global.c serial.c system.c
  group Include
    Include/: app_error.h appconfig.h boardconfig.h main.h svc_app.h system_nRF51.h
  group SDK/Include
    SDK/Include/: compiler_abstraction.h nordic_common.h nrf.h nrf51.h nrf51_bitfields.h nrf51_deprecated.h nrf_assert.h nrf_delay.h nrf_gpio.h system_nrf51.h
  group SDK/Include/S210
    SDK/Include/s210/: ant_error.h ant_interface.h ant_parameters.h nrf_error.h nrf_error_sdm.h nrf_error_soc.h nrf_radio_disable.h nrf_sdm.h nrf_soc.h nrf_svc.h softdevice_assert.h
  group Source
    Source/: iar_startup_nrf51.s main.c nRF51422_QFAA.icf system_nrf51.c version.c
