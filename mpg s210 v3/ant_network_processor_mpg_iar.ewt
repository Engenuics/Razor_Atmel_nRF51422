<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Common</name>
    <group>
      <name>Include</name>
      <file>
        <name>$PROJ_DIR$\Common\Include\command.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Include\dsi_utility.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Include\global.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Include\serial.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Include\system.h</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\Common\Source\command.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Source\dsi_utility.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Source\global.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Source\serial.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Common\Source\system.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Include</name>
    <file>
      <name>$PROJ_DIR$\Include\app_error.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\appconfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\boardconfig.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\main.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\svc_app.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Include\system_nRF51.h</name>
    </file>
  </group>
  <group>
    <name>SDK</name>
    <group>
      <name>Include</name>
      <group>
        <name>S210</name>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\ant_error.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\ant_interface.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\ant_parameters.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\nrf_error.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\nrf_error_sdm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\nrf_error_soc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\nrf_radio_disable.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\nrf_sdm.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\nrf_soc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\nrf_svc.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SDK\Include\s210\softdevice_assert.h</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\SDK\Include\compiler_abstraction.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nordic_common.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nrf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nrf51.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nrf51_bitfields.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nrf51_deprecated.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nrf_assert.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nrf_delay.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\nrf_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SDK\Include\system_nrf51.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>Source</name>
    <file>
      <name>$PROJ_DIR$\Source\iar_startup_nrf51.s</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\nRF51422_QFAA.icf</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\system_nrf51.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\Source\version.c</name>
    </file>
  </group>
</project>


