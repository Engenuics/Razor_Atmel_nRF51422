<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ant_network_processor_mpg_iar.ewp</path>
  </project>
  <batchBuild/>
</workspace>


